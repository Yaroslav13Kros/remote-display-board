# Keil uVision project controlPane.uvprojx, settings and files
target controlPane (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: controlPane
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F030x6
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: gpio.c spi.c stm32f0xx_hal_msp.c main.c stm32f0xx_it.c usart.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_pwr.c stm32f0xx_ll_usart.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_rcc.c stm32f0xx_ll_utils.c stm32f0xx_hal_flash.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash_ex.c stm32f0xx_ll_exti.c stm32f0xx_ll_dma.c stm32f0xx_ll_spi.c stm32f0xx_hal_dma.c stm32f0xx_hal_tim.c stm32f0xx_hal.c stm32f0xx_ll_gpio.c stm32f0xx_hal_cortex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_pwr_ex.c stm32f0xx_ll_rcc.c stm32f0xx_hal_tim_ex.c
  group Application/MDK-ARM
    ./: startup_stm32f030x6.s
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
software components: CMSIS:CORE 4.1.0
